Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 2018_01
Time: 2021-03-17T11:20:50
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 24.30.37300.0000 - Exporter 20.0.0.364 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Mar 17 11:20:50 2021 * Host: WLOH16-009 * Database: C:\Users\AticE\AppData\Local\Temp\d49c62f5-2201-4bf9-a585-f4c923bdc050\c41f4931-e4a3-4a98-a00f-a799d3032617\ifc * Database version: 5507 * Database creation date: Wed Mar 17 11:20:46 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Mar 17 11:20:46 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Mar 17 11:20:46 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 2018_01
Phase: Projekt Status

# IfcSite, Default
RefLatitude: 48, 8, 15, 359802; RefLongitude: 11, 34, 47, 783432; RefElevation: 519 m
Sonstige - Auftraggeber: Bauherr; Kategorie: Projektinformationen; Projektadresse: Projektadresse; Projektausgabedatum: Projekt Datum; Projektnummer: 2018_01; Projektstatus: Projekt Status; Verfasser eMail: E-Mail; Verfasser Firma 1: AUTODESK GmbH; Verfasser PLZ Ort: Ort; Verfasser Strasse: Adresse; Verfasser Telefon: Telefon; Verfasser URL: www.Autodesk.de/BIM
Text - Bauherr: AUTODESK; Baustellenort: BAUORT; Baustellenstraße: BAUSTRASSE 1; Einlagezahl: 123-45; Gerichtsbezirk: GERICHTSBEZIRK; Grundstücksnummer: GR; Katastralgemeinde: KG; Kundenadresse: KUNDENSTRASSE 1; Kundenort: KUNDENORT; Kundentelefon: 0000-00000-1; Kundenzusatz: KUNDENZUSATZ

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 0
Sonstige - Kategorie: Projektinformationen; Auftraggeber: Bauherr; Projektadresse: Projektadresse; Projektausgabedatum: Projekt Datum; Projektnummer: 2018_01; Projektstatus: Projekt Status; Verfasser eMail: E-Mail; Verfasser Firma 1: AUTODESK GmbH; Verfasser PLZ Ort: Ort; Verfasser Strasse: Adresse; Verfasser Telefon: Telefon; Verfasser URL: www.Autodesk.de/BIM
Text - Bauherr: AUTODESK; Baustellenort: BAUORT; Baustellenstraße: BAUSTRASSE 1; Einlagezahl: 123-45; Gerichtsbezirk: GERICHTSBEZIRK; Grundstücksnummer: GR; Katastralgemeinde: KG; Kundenadresse: KUNDENSTRASSE 1; Kundenort: KUNDENORT; Kundentelefon: 0000-00000-1; Kundenzusatz: KUNDENZUSATZ

# IfcBuildingElementProxy: Norm, Familie1:Norm:2405756
Type - Material: Stahl, Schnee
Type - Abhängigkeiten - Vorgabe-Ansicht: 0 m
Type - ID-Daten - Typname: Norm
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Familie1
Type - Pset_BuildingElementProxyCommon - Reference: Norm
Type - Pset_QuantityTakeOff - Reference: Norm
Pset_BuildingElementProxyCommon - sets with these values: 2
Abhängigkeiten - Basisbauteil: Keine; Höhe von Ebene: 0 m; Versatz von Host: 0 m; Verschieben mit umliegenden Elementen: no
Abmessungen - Fläche: 0.858363 m2; Volumen: 0.00907901 m3
Phasen - Phase erstellt: Phase 2
Sonstige - Familie: Familie1: Norm; Familie und Typ: Familie1: Norm; Typ: Familie1: Norm; Typ-ID: Familie1: Norm
